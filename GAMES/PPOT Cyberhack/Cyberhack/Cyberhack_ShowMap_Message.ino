#include "src/utils/Arduboy2Ext.h"

constexpr char word_000[] PROGMEM = "\n";
constexpr char word_001[] PROGMEM = "I";
constexpr char word_002[] PROGMEM = "NEED";
constexpr char word_003[] PROGMEM = "TO";
constexpr char word_004[] PROGMEM = "TAKE";
constexpr char word_005[] PROGMEM = "THAT";
constexpr char word_006[] PROGMEM = "CORP";
constexpr char word_007[] PROGMEM = "DOWN";
constexpr char word_008[] PROGMEM = "AT";
constexpr char word_009[] PROGMEM = "ALL";
constexpr char word_010[] PROGMEM = "COSTS!";
constexpr char word_011[] PROGMEM = "DAMN,";
constexpr char word_012[] PROGMEM = "WASN'T";
constexpr char word_013[] PROGMEM = "PERPARED";
constexpr char word_014[] PROGMEM = "BREACH";
constexpr char word_015[] PROGMEM = "THROUGH";
constexpr char word_016[] PROGMEM = "THIS.";
constexpr char word_017[] PROGMEM = "UP";
constexpr char word_018[] PROGMEM = "GOES";
constexpr char word_019[] PROGMEM = "MY";
constexpr char word_020[] PROGMEM = "THREAT";
constexpr char word_021[] PROGMEM = "LEVEL!";
constexpr char word_022[] PROGMEM = "THANK";
constexpr char word_023[] PROGMEM = "YOU";
constexpr char word_024[] PROGMEM = "FOR";
constexpr char word_025[] PROGMEM = "THE";
constexpr char word_026[] PROGMEM = "INTEL!";
constexpr char word_027[] PROGMEM = "WILL";
constexpr char word_028[] PROGMEM = "WITH";
constexpr char word_029[] PROGMEM = "YOUR";
constexpr char word_030[] PROGMEM = "OWN";
constexpr char word_031[] PROGMEM = "SHIT!";
constexpr char word_032[] PROGMEM = "NOW";
constexpr char word_033[] PROGMEM = "TERRY,";
constexpr char word_034[] PROGMEM = "MAKE";
constexpr char word_035[] PROGMEM = "IT";
constexpr char word_036[] PROGMEM = "HOME.";
constexpr char word_037[] PROGMEM = "JUST";
constexpr char word_038[] PROGMEM = "INTEL";
constexpr char word_039[] PROGMEM = "AVOID";
constexpr char word_040[] PROGMEM = "NCPD'S";
constexpr char word_041[] PROGMEM = "LAMEST.";
constexpr char word_042[] PROGMEM = "HACK";
constexpr char word_043[] PROGMEM = "THEIR";
constexpr char word_044[] PROGMEM = "SYSTEMS";
constexpr char word_045[] PROGMEM = "MORE";
constexpr char word_046[] PROGMEM = "WHAT";
constexpr char word_047[] PROGMEM = "HELL,";
constexpr char word_048[] PROGMEM = "CAN'T";
constexpr char word_049[] PROGMEM = "EVEN";
constexpr char word_050[] PROGMEM = "GET";
constexpr char word_051[] PROGMEM = "HOME";
constexpr char word_052[] PROGMEM = "WITHOUT";
constexpr char word_053[] PROGMEM = "A";
constexpr char word_054[] PROGMEM = "FIGHT!";
constexpr char word_055[] PROGMEM = "LET'S";
constexpr char word_056[] PROGMEM = "HIT";
constexpr char word_057[] PROGMEM = "WHERE";
constexpr char word_058[] PROGMEM = "HURTS.";
constexpr char word_059[] PROGMEM = "HOW";
constexpr char word_060[] PROGMEM = "MUCH";
constexpr char word_061[] PROGMEM = "UNCOVER";
constexpr char word_062[] PROGMEM = "TODAY.";
constexpr char word_063[] PROGMEM = "SELL";
constexpr char word_064[] PROGMEM = "THEM";
constexpr char word_065[] PROGMEM = "DOWN.";
constexpr char word_066[] PROGMEM = "HE";
constexpr char word_067[] PROGMEM = "CAN";
constexpr char word_068[] PROGMEM = "CLEAR";
constexpr char word_069[] PROGMEM = "NAME..";
constexpr char word_070[] PROGMEM = "PRICE.";
constexpr char word_071[] PROGMEM = "WHEN";
constexpr char word_072[] PROGMEM = "PAYING";
constexpr char word_073[] PROGMEM = "RIGHT";
constexpr char word_074[] PROGMEM = "PEOPLE";
constexpr char word_075[] PROGMEM = "LOWER";
constexpr char word_076[] PROGMEM = "LEVEL";
constexpr char word_077[] PROGMEM = "HERE.";
constexpr char word_078[] PROGMEM = "HOPE";
constexpr char word_079[] PROGMEM = "FIND";
constexpr char word_080[] PROGMEM = "CONTACT";
constexpr char word_081[] PROGMEM = "HELP";
constexpr char word_082[] PROGMEM = "ME";
constexpr char word_083[] PROGMEM = "OUT.";
constexpr char word_084[] PROGMEM = "LET'S";
constexpr char word_085[] PROGMEM = "SHOPS.";
constexpr char word_086[] PROGMEM = "SOME";
constexpr char word_087[] PROGMEM = "UPGRADES.";
constexpr char word_088[] PROGMEM = "THERE";
constexpr char word_089[] PROGMEM = "GETTING";
constexpr char word_090[] PROGMEM = "CAUGHT.";
constexpr char word_091[] PROGMEM = "IF";
constexpr char word_092[] PROGMEM = "AM";
constexpr char word_093[] PROGMEM = "STUCK,";
constexpr char word_094[] PROGMEM = "REMOTE";
constexpr char word_095[] PROGMEM = "HACKING";
constexpr char word_096[] PROGMEM = "MIGHT";
constexpr char word_097[] PROGMEM = "THOSE";
constexpr char word_098[] PROGMEM = "CORPO";
constexpr char word_099[] PROGMEM = "BASTARDS";
constexpr char word_100[] PROGMEM = "PAY";
constexpr char word_101[] PROGMEM = "THEY";
constexpr char word_102[] PROGMEM = "HAVE";
constexpr char word_103[] PROGMEM = "DONE.";
constexpr char word_104[] PROGMEM = "BY";
constexpr char word_105[] PROGMEM = "SERVERS";
constexpr char word_106[] PROGMEM = "AND";
constexpr char word_107[] PROGMEM = "GOOD.";
constexpr char word_108[] PROGMEM = "ALLOW";
constexpr char word_109[] PROGMEM = "FURTHER.";
constexpr char word_110[] PROGMEM = "ONCE";
constexpr char word_111[] PROGMEM = "HACKS";
constexpr char word_112[] PROGMEM = "BEEN";
constexpr char word_113[] PROGMEM = "COMPLETED.";
constexpr char word_114[] PROGMEM = "PURCHASE";
constexpr char word_115[] PROGMEM = "OR";
constexpr char word_116[] PROGMEM = "SWAP";
constexpr char word_117[] PROGMEM = "CONTINUE";
constexpr char word_118[] PROGMEM = "CANNOT";
constexpr char word_119[] PROGMEM = "AFFORD";
constexpr char word_120[] PROGMEM = "ANY";
constexpr char word_121[] PROGMEM = "UNFORTUNATELY,";
constexpr char word_122[] PROGMEM = "TIME";
constexpr char word_123[] PROGMEM = "HERE";
constexpr char word_124[] PROGMEM = "IS";
constexpr char word_125[] PROGMEM = "OVER!";
constexpr char word_126[] PROGMEM = "CONGRATULATIONS!";
constexpr char word_127[] PROGMEM = "TOOK";
constexpr char word_128[] PROGMEM = "BALANCE";
constexpr char word_129[] PROGMEM = "OF";

constexpr char word_130[] PROGMEM = "NO~DECK ";
constexpr char word_131[] PROGMEM = "DECK~V1 ";
constexpr char word_132[] PROGMEM = "DECK~V2 ";
constexpr char word_133[] PROGMEM = "DECK~V3 ";
constexpr char word_134[] PROGMEM = "HACKING\nCYBERDECKS\nSAVE";
constexpr char word_135[] PROGMEM = "MOVE HERE";
constexpr char word_136[] PROGMEM = "-~SOLD~OUT~-\n";

#ifdef CREDITS

constexpr char word_137[] PROGMEM = " CYBERHACK: PPOT~2021";
constexpr char word_138[] PROGMEM = "  DEVELOPER:~FILMOTE";
constexpr char word_139[] PROGMEM = " ~GRAPHICS:~VAMPIRICS ";
constexpr char word_140[] PROGMEM = "TESTING:~TUXINATOR2009";
constexpr char word_141[] PROGMEM = "MORAL~SUPPORT:~JESSICA";

#endif

constexpr const char * words[] PROGMEM {
	word_000, word_001, word_002, word_003, word_004, word_005, word_006, word_007, 
	word_008, word_009, word_010, word_011,	word_012, word_013, word_014, word_015,
	word_016, word_017, word_018, word_019,	word_020, word_021, word_022, word_023,
	word_024, word_025, word_026, word_027,	word_028, word_029, word_030, word_031,
	word_032, word_033, word_034, word_035,	word_036, word_037, word_038, word_039,
	word_040, word_041, word_042, word_043,	word_044, word_045, word_046, word_047,
	word_048, word_049, word_050, word_051,	word_052, word_053, word_054, word_055,
	word_056, word_057, word_058, word_059,	word_060, word_061, word_062, word_063,
	word_064, word_065, word_066, word_067,	word_068, word_069, word_070, word_071,
    word_072, word_073, word_074, word_075, word_076, word_077, word_078, word_079, 
    word_080, word_081, word_082, word_083, word_084, word_085, word_086, word_087, 
    word_088, word_089, word_090, word_091, word_092, word_093, word_094, word_095, 
    word_096, word_097, word_098, word_099, word_100, word_101, word_102, word_103, 
    word_104, word_105, word_106, word_107, word_108, word_109, word_110, word_111, 
    word_112, word_113, word_114, word_115, word_116, word_117, word_118, word_119, 
    word_120, word_121, word_122, word_123, word_124, word_125, word_126, word_127,
    word_128, word_129, word_130, word_131, word_132, word_133, word_134, word_135,
    word_136,

    #ifdef CREDITS
    word_137, word_138, word_139, word_140, word_141, 
    #endif

};

constexpr uint8_t sentence_00_Length = 11;
constexpr uint8_t sentence_01_Length = 13;
constexpr uint8_t sentence_02_Length = 13;
constexpr uint8_t sentence_03_Length = 12;
constexpr uint8_t sentence_04_Length = 8;
constexpr uint8_t sentence_05_Length = 7;
constexpr uint8_t sentence_06_Length = 11;
constexpr uint8_t sentence_07_Length = 16;
constexpr uint8_t sentence_08_Length = 14;
constexpr uint8_t sentence_09_Length = 11;
constexpr uint8_t sentence_10_Length = 10;
constexpr uint8_t sentence_11_Length = 12;
constexpr uint8_t sentence_12_Length = 12;
constexpr uint8_t sentence_13_Length = 13;
constexpr uint8_t sentence_14_Length = 21;
constexpr uint8_t sentence_15_Length = 15;
constexpr uint8_t sentence_16_Length = 15;
constexpr uint8_t sentence_17_Length = 16;
constexpr uint8_t sentence_18_Length = 14;
constexpr uint8_t sentence_19_Length = 12;
constexpr uint8_t sentence_20_Length = 7;
constexpr uint8_t sentence_21_Length = 16;

constexpr uint8_t sentences_Lengths[] PROGMEM {
	sentence_00_Length, sentence_01_Length, sentence_02_Length, sentence_03_Length, sentence_04_Length, sentence_05_Length, 
    sentence_06_Length, sentence_07_Length, sentence_08_Length, sentence_09_Length, sentence_10_Length, sentence_11_Length,
    sentence_12_Length, sentence_13_Length, sentence_14_Length, sentence_15_Length, sentence_16_Length, sentence_17_Length,
    sentence_18_Length, sentence_19_Length, sentence_20_Length, sentence_21_Length,  
};

constexpr uint8_t sentence_data[] PROGMEM { 
1, 2, 3, 4, 5, 0, 6, 7, 8, 9, 10,                                                       // 00 I need to take that corp down at all costs!
32, 3, 34, 35, 36, 0, 37, 2, 3, 39, 0, 40, 41,                                          // 01 Now to make it home. Just need to avoid NCPDs lamest.
2, 3, 34, 35, 36, 0, 42, 43, 44, 24, 0, 45, 26,                                         // 02 Need to make it home, hack their system for more intel.
46, 25, 47, 48, 0, 49, 50, 51, 52, 53, 0, 54,                                           // 03 What the hell, can’t even get home without a fight!
55, 56, 25, 06, 57, 0, 35, 58,                                                          // 04 Let’s hit the Corp where it hurts.
59, 60, 27, 1, 61, 0, 62 ,                                                              // 05 How much will I uncover today.
1, 2, 45, 38, 3, 63, 0, 3, 4, 64, 65,                                                   // 06 I need more intel to sell to take them down.
1, 2, 3, 50, 3, 33, 0, 66, 67, 68, 19, 69, 0, 24, 53, 70,                               // 07 I need to get to Terry, he can clear my name… for a price.
71, 72, 25, 73, 0, 74, 1, 67, 75, 19, 0, 20, 76, 77,                                    // 08 When paying the right people I can lower my threat level here.
78, 1, 27, 79, 5, 0, 80, 3, 81, 82, 83,                                                 // 09 Hope I will find that contact to help me out.
84, 50, 3, 25, 85, 0, 1, 2, 86, 87,                                                     // 10 Let’s get to the shops. I need some upgrades.
2, 87, 37, 2, 0, 3, 50, 88, 52, 0, 89, 90 ,                                             // 11 Need upgrades. Just need to get there without getting caught.
91, 1, 92, 93, 94, 0, 95, 96, 81, 82, 0, 83,                                            // 12 If I am stuck, remote hacking might help me out.
97, 98, 99, 0, 2, 3, 100, 24, 46, 0, 101, 102, 103,                                     // 13 Those CORPO bastards need to pay for what they have done. 
104, 95, 43, 105, 0, 1, 67, 79, 38, 106, 0, 63, 35, 3, 108, 82, 3, 0, 42, 64, 109,      // 14 By hacking their servers I can find Intel and sell it to allow me to hack them further.
110, 1, 102, 46, 1, 2, 1, 0, 67, 4, 64, 7, 24, 0, 107,                                  // 15 Once I have what I need I can take them down for good.
11, 1, 12, 13, 0, 3, 14, 15, 16, 0, 17, 18, 19, 20, 21,                                 // 16 Damn, I wasn’t prepare to breach through this. Up goes my threat level…
22, 23, 24, 25, 26, 0, 1, 27, 4, 23, 7, 0, 28, 29, 30, 31,                              // 17 Thank you for the intel! I will take you down with your own shit!
9, 111, 102, 112, 0, 113, 3, 117, 0, 114, 115, 116, 0, 87,                              // All hacks have been completed. To continue purchase or swap upgrades.
9, 111, 113, 0, 121, 23, 0, 118, 119, 120, 0, 87,                                       // All hacks completed. Unfortunately, You cannot afford any upgrades.
121, 29, 0, 122, 123, 124, 125,                                                         // Unfortunately, your time here is over. 
126, 0, 9, 111, 113, 0, 23, 127, 25, 6, 7, 0, 28, 53, 128, 129,                         // Congratulations! All Hacks completed. You took the Corp down with a balance of
};


inline FlashStringHelper readFlashStringPointer(const char * const * flashString) noexcept {
	return static_cast<FlashStringHelper>(pgm_read_ptr(flashString));
}

void print(Print & printer, uint8_t wordIndex) {
	printer.print(readFlashStringPointer(&words[wordIndex]));
}

void println(Print & printer, uint8_t wordIndex) {
    print(printer, wordIndex);
    printer.print("\n");
}

void showMap_Message_Init() {

    clearLEDs();
    mapGameVars.counter = 1;
    gameState = static_cast<GameState>(static_cast<uint8_t>(gameState) + static_cast<uint8_t>(GameState::Messages_End) - static_cast<uint8_t>(GameState::Messages_Start) + 1);

    #ifdef BYTE_BEAT_SOUNDS_3
    byteBeatIdx = ByteBeatIndex::Map;
    #endif

}

void showMap_Message() {

    uint8_t y = 33;
    uint16_t startingPos = 0;
    
    renderDistricts();
    
    arduboy.fillRect(0, 27, WIDTH, HEIGHT, BLACK);
    arduboy.drawFastHLine(0, 28, WIDTH);
    arduboy.drawFastHLine(35, 30, 80);
    arduboy.drawFastVLine(35, 30, 26);
    
    Sprites::drawOverwrite(35, 54, Images::DownFade, 0);
    Sprites::drawOverwrite(116, 30, Images::RightFade2, 0);

    font3x5.setCursor(39, y);

    for (uint8_t i = 0; i < static_cast<uint8_t>(mapGameVars.getMessage()); i++) {
        startingPos = startingPos + pgm_read_byte(&sentences_Lengths[i]);
    }

    for (uint16_t i = startingPos; i < startingPos + mapGameVars.counter; i++) {

        if (pgm_read_byte(&sentence_data[i]) == 0) {

            y = y + 7;
            font3x5.setCursor(39, y);

        }
        else {

            print(font3x5, pgm_read_byte(&sentence_data[i]));
            font3x5.print(F("~"));

        }

    }

    uint8_t sentenceLength = pgm_read_byte(&sentences_Lengths[static_cast<uint8_t>(mapGameVars.getMessage())]);

    switch (mapGameVars.getMessage()) {

        case Message::Face_Player_Start ... Message::Face_Player_End:
            Sprites::drawOverwrite(0, 30, Images::Portrait_00, 0);
            if (mapGameVars.counter < sentenceLength && arduboy.getFrameCountHalf(8)) {

                Sprites::drawOverwrite(11, 47, Images::Portrait_01, 0);

            }
            break;

        default:
            Sprites::drawOverwrite(6, 32, Images::MapMenu_Face_00, 0);
            arduboy.drawFastHLine(0, 63, 36);
            if (mapGameVars.counter < sentenceLength && arduboy.getFrameCountHalf(8)) {

                Sprites::drawOverwrite(17, 49, Images::MapMenu_Face_01, 0);

            }
            break;

    }

    if (arduboy.isFrameCount(6)) {
        if (sentenceLength > mapGameVars.counter) {
            mapGameVars.counter++;
        }
    }

    if (mapGameVars.getMessage() == Message::Game_Over_Success && sentenceLength == mapGameVars.counter) {

        font3x5.setCursor(103, 54);
        font3x5.print(player.getDollars());
        font3x5.print("!");

    }

    if (arduboy.justPressed(B_BUTTON)) {

        if (mapGameVars.counter < sentenceLength) {
    
            mapGameVars.counter = sentenceLength;

        }
        else {

            handleTransition();

        }

    }

    if (arduboy.justPressed(A_BUTTON)) {

        handleTransition();

    }

}

void handleTransition() {

    switch (gameState) {

        case GameState::Message_Intro:

            switch (mapGameVars.getMessage()) {

                case Message::Intro_1:
                    mapGameVars.setMessage(Message::Intro_2);
                    break;

                case Message::Intro_2:
                    mapGameVars.setMessage(Message::Intro_3);
                    break;

                case Message::Intro_3:
                    gotoMap();
                    break;

                default: break;
                    
            }

            break;

        case GameState::Message_Hack_Target_Not_Achieved:

            if (player.getThreatLevel() == 100) {
                gameState = GameState::Message_Game_Over_Init;
                mapGameVars.setMessage(Message::Game_Over);
            }
            else {
                gotoMap();
            }
            break;

        case GameState::Message_Hacks_Achieved:
            gotoMap();
            break;

        case GameState::Message_Move_To_Hacking:

            switch (mapGameVars.getMessage()) {

                case Message::Hack_None_Available:

                    gotoMap();
                    break;

                default:
                    gameState = GameState::HackGame_Init;
                    break;
            
            }
            break;

        case GameState::Message_Game_Over:
            #ifdef BYTE_BEAT_SOUNDS    
                disableByteBeat();
            #endif
            break;

        case GameState::Message_Game_Over_Success:
            gameState = GameState::Credits_Init;
            #ifdef BYTE_BEAT_SOUNDS    
                disableByteBeat();
            #endif
            break;

        case GameState::Message_Hacks_Game_Over:
            gameState = GameState::Message_Game_Over_Init;
            mapGameVars.setMessage(Message::Game_Over);
            break;

        default:
            gameState = GameState::StealthGame_Init;
            break;

    }

}